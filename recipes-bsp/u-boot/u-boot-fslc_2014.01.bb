include u-boot-fslc.inc

PV = "v2014.01"

SRCBRANCH = "patches-2014.01"

SRCREV = "9e76b3808bce73f36f40ad8a3e06f7006037c386"
